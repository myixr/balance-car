# Keil uVision project stm32.uvprojx, settings and files
target stm32 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm32
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB,MOTION_DRIVER_TARGET_STM32,MPU6050
  c misc: --C99
  c include: ../Inc;          ../Drivers/STM32F1xx_HAL_Driver/Inc;          ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;          ../Drivers/CMSIS/Include;          ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;          ..\user;          ..\user\modbus\include;          ..\user\modbus\rtu;          ..\user\modbus-port
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_uart.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_i2c.c stm32f1xx_hal_pwr.c
  group User
    ../user/: led.c mpu6050.c user.c motor_driver.c
    ../user/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../user/modbus/: mb.c
    ../user/modbus/rtu/: mbrtu.c mbcrc.c
    ../user/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../user/modbus-port/: portevent.c portserial.c porttimer.c
  group Drivers/CMSIS
    ../Drivers/CMSIS//Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group Application/User
    ../Src/: gpio.c main.c usart.c stm32f1xx_hal_msp.c stm32f1xx_it.c i2c.c tim.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
software components: CMSIS:CORE 4.1.0
